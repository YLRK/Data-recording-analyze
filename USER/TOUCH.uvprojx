# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx, __RTTHREAD__
  c misc: --diag_suppress=111  --diag_suppress=550 --diag_suppress=68
  c include: ..\CORE;..\OBJ;..\USER;..\USMART;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\board;..\HALLIB\HAL_Drivers\config;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\TIMER;..\HALLIB\HAL_Drivers;..\HARDWARE\XMRAM;..\HARDWARE\Inc;..\Packages\cpu_usage-latest;..\Packages\SignalLed-latest\inc;..\Packages\SystemView-latest\SystemView_Src\SEGGER;..\Packages\SystemView-latest\SystemView_Src\Config;..\GUI;..\GUI\lvgl;..\GUI\lv_examples;..\GUI\lvgl_driver;..\GUI_APP\FONT;..\GUI_APP\IMG;..\GUI_APP\WIN;..\GUI_APP\Inc;..\RT-Thread\include;..\RT-Thread\components\finsh;..\RT-Thread\components\dfs\include;..\RT-Thread\components\dfs\filesystems\devfs;..\RT-Thread\components\dfs\filesystems\elmfat;..\RT-Thread\components\drivers\include;..\RT-Thread\components\drivers\spi\sfud\inc;..\RT-Thread\components\drivers\include;..\RT-Thread\components\libc\compilers\armlibc;..\RT-Thread\components\libc\compilers\common;..\RT-Thread\components\drivers\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h startup_stm32f407xx.s
    ../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../RT-Thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
  group DeviceDrivers
    ../RT-Thread/components/drivers/misc/: pin.c
    ../RT-Thread/components/drivers/serial/: serial.c
    ../RT-Thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../RT-Thread/components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c spi_flash_sfud.c
    ../RT-Thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../RT-Thread/components/drivers/sdio/: mmcsd_core.c sd.c sdio.c mmc.c block_dev.c
  group Kernel
    ../RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group HALLIB
    ./: stm32f4xx_hal_conf.h
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group Drivers
    ../SYSTEM/board/: board.c
    ../HALLIB/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_spi.c drv_sdio.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
    ../SYSTEM/usart/: usart.c
  group finsh
    ../RT-Thread/components/finsh/: shell.c cmd.c msh.c symbol.c msh_file.c
    ../Packages/donut-latest/: donut.c
  group XMRAM
    ../HARDWARE/XMRAM/: XMRAM.h XMRAM.lib
  group Filesystem
    ../RT-Thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../RT-Thread/components/dfs/filesystems/devfs/: devfs.c
    ../RT-Thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group SYSTEMVIEW
    ../Packages/SystemView-latest/SystemView_Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../Packages/SystemView-latest/SystemView_Src/Config/: SEGGER_RTT_Device.c SEGGER_SYSVIEW_Config_RTThread.c SEGGER_SYSVIEW_RTThread.c
    ../SYSTEM/sys/: sys.c
  group GUI
    ../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    ../GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TOUCH/: touch.c ott2001a.c ctiic.c ft5206.c gt9147.c
    ../HARDWARE/Src/: rtc.c sram.c dht11.c dht22.c spi.c w25qxx.c sdio_sdcard.c
    ../HARDWARE/TIMER/: timerout.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
  group Packages
    ../Packages/SignalLed-latest/src/: signal_led.c
    ../Packages/cpu_usage-latest/: cpu_usage.c cpu_usage_cmd.c
  group GUI_APP
    ../GUI_APP/Src/: app.c menu.c
    ../GUI_APP/WIN/: calendar_win.c chart_win.c gauge_win.c login_win.c main_win.c file_win.c progress_win.c
    ../GUI_APP/IMG/: file_img.c chart_img.c date_img.c gauge_img.c logo_img.c progress_img.c weixin_img.c
    ../GUI_APP/FONT/: my_font.c
    ../GUI/: lv_conf.h lv_ex_conf.h
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c main.h rtconfig.h
